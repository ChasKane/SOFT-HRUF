* /Users/sharks/Documents/SoftHRUF/SoftHRUF.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Thursday, January 07, 2016 'AMt' 12:17:46 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
D3  Net-_D1-Pad1_ Net-_D14-Pad2_ D
D4  Net-_D1-Pad1_ Net-_D15-Pad2_ D
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ D
D2  Net-_D1-Pad1_ Net-_D13-Pad2_ D
D5  Net-_D1-Pad1_ Net-_D16-Pad2_ D
D25  Net-_D23-Pad1_ Net-_D14-Pad2_ D
D26  Net-_D23-Pad1_ Net-_D15-Pad2_ D
D23  Net-_D23-Pad1_ Net-_D1-Pad2_ D
D24  Net-_D23-Pad1_ Net-_D13-Pad2_ D
D27  Net-_D23-Pad1_ Net-_D16-Pad2_ D
D14  Net-_D12-Pad1_ Net-_D14-Pad2_ D
D15  Net-_D12-Pad1_ Net-_D15-Pad2_ D
D12  Net-_D12-Pad1_ Net-_D1-Pad2_ D
D13  Net-_D12-Pad1_ Net-_D13-Pad2_ D
D16  Net-_D12-Pad1_ Net-_D16-Pad2_ D
D9  Net-_D1-Pad1_ Net-_D20-Pad2_ D
D10  Net-_D1-Pad1_ Net-_D10-Pad2_ D
D7  Net-_D1-Pad1_ Net-_D18-Pad2_ D
D8  Net-_D1-Pad1_ Net-_D19-Pad2_ D
D11  Net-_D1-Pad1_ Net-_D11-Pad2_ D
D31  Net-_D23-Pad1_ Net-_D20-Pad2_ D
D32  Net-_D23-Pad1_ Net-_D10-Pad2_ D
D29  Net-_D23-Pad1_ Net-_D18-Pad2_ D
D30  Net-_D23-Pad1_ Net-_D19-Pad2_ D
D33  Net-_D23-Pad1_ Net-_D11-Pad2_ D
D20  Net-_D12-Pad1_ Net-_D20-Pad2_ D
D21  Net-_D12-Pad1_ Net-_D10-Pad2_ D
D18  Net-_D12-Pad1_ Net-_D18-Pad2_ D
D19  Net-_D12-Pad1_ Net-_D19-Pad2_ D
D22  Net-_D12-Pad1_ Net-_D11-Pad2_ D
D6  Net-_D1-Pad1_ Net-_D17-Pad2_ D
D28  Net-_D23-Pad1_ Net-_D17-Pad2_ D
D17  Net-_D12-Pad1_ Net-_D17-Pad2_ D

.end
